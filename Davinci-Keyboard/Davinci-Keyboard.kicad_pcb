# Repository koki0517/Davinci-Keyboard

## KiCad design Davinci-Keyboard/Davinci-Keyboard.kicad_pcb

Parts:
C9, C10, C11, C12, C13, C14: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
EN1, EN2, EN3: RotaryEncoder_Switch; RotaryEncoder_EC11-Switch
R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3.3V: EN1.S1, EN2.S1, EN3.S1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1; also elsewhere on the board
/ESP32-S3/enc1_A_IO41: C9.1, R18.2; also elsewhere on the board
/ESP32-S3/enc1_B_IO42: C10.1, R19.1; also elsewhere on the board
/ESP32-S3/enc1_SW_IO38: EN1.S2, R24.1; also elsewhere on the board
/ESP32-S3/enc2_A_IO39: C11.1, R20.2; also elsewhere on the board
/ESP32-S3/enc2_B_IO40: C12.1, R21.1; also elsewhere on the board
/ESP32-S3/enc2_SW_IO48: EN2.S2, R25.1; also elsewhere on the board
/ESP32-S3/enc3_A_IO2: C13.1, R22.2; also elsewhere on the board
/ESP32-S3/enc3_B_IO1: C14.1, R23.1; also elsewhere on the board
/ESP32-S3/enc3_SW_IO47: EN3.S2, R26.1; also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, EN1.C, EN2.C, EN3.C, R24.2, R25.2, R26.2; also elsewhere on the board
unnamed: EN1.A, R12.2, R18.1
unnamed: EN1.B, R13.2, R19.2
unnamed: EN2.A, R14.2, R20.1
unnamed: EN2.B, R15.2, R21.2
unnamed: EN3.A, R16.2, R22.1
unnamed: EN3.B, R17.2, R23.2

Parts:
C1, C2, C4, C6, C8: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C7: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: OSG50603C1E; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
Q1, Q2: BSS138; SOT-23
Q3, Q4, Q5, Q6: MMBT3906; SOT-23
R1, R4: 5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7, R8, R9, R10, R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
S1: BOOT; SW_SKRPACE010
S2: RST; SW_SKRPACE010
U1: CH340K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm
U2: FDS4935A; SO-8_ONS-L
U3: AZ1117CH-3.3TRG1; SOT-223_DIO-M
U4: ESP32-S3-WROOM-1

Connections:
+3.3V: C5.1, C7.1, C8.1, R11.2, U3.2 (OUTPUT), U4.2 (3V3); also elsewhere on the board
/ESP32-S3/D+: J2.A6 (D+), J2.B6 (D+), U1.1 (UD+)
/ESP32-S3/D-: J2.A7 (D-), J2.B7 (D-), U1.2 (UD-)
/ESP32-S3/DTR: Q2.2 (S), R5.1, U1.4 (~DTR)
/ESP32-S3/IO0: C6.1, Q2.3 (D), S2.3, S2.4, U4.27 (IO0)
/ESP32-S3/IO4: U4.4 (IO4); also elsewhere on the board
/ESP32-S3/IO5: U4.5 (IO5); also elsewhere on the board
/ESP32-S3/IO6: U4.6 (IO6); also elsewhere on the board
/ESP32-S3/IO7: U4.7 (IO7); also elsewhere on the board
/ESP32-S3/IO8: U4.12 (IO8); also elsewhere on the board
/ESP32-S3/IO9: U4.17 (IO9); also elsewhere on the board
/ESP32-S3/IO10: U4.18 (IO10); also elsewhere on the board
/ESP32-S3/IO11: U4.19 (IO11); also elsewhere on the board
/ESP32-S3/IO12: U4.20 (IO12); also elsewhere on the board
/ESP32-S3/IO13: U4.21 (IO13); also elsewhere on the board
/ESP32-S3/IO14: U4.22 (IO14)
/ESP32-S3/IO15: U4.8 (IO15); also elsewhere on the board
/ESP32-S3/IO16: U4.9 (IO16); also elsewhere on the board
/ESP32-S3/IO17: U4.10 (IO17); also elsewhere on the board
/ESP32-S3/IO18: U4.11 (IO18); also elsewhere on the board
/ESP32-S3/IO21: U4.23 (IO21)
/ESP32-S3/RTS: Q1.2 (S), R6.1, U1.6 (~RTS)
/ESP32-S3/RX: U1.8 (TXD), U4.36 (RXD0)
/ESP32-S3/TX: U1.9 (RXD), U4.37 (TXD0)
/ESP32-S3/en: C4.1, Q1.3 (D), R11.1, S1.3, S1.4, U4.3 (EN)
/ESP32-S3/enc1_A_IO41: U4.34 (IO41); also elsewhere on the board
/ESP32-S3/enc1_B_IO42: U4.35 (IO42); also elsewhere on the board
/ESP32-S3/enc1_SW_IO38: U4.31 (IO38); also elsewhere on the board
/ESP32-S3/enc2_A_IO39: U4.32 (IO39); also elsewhere on the board
/ESP32-S3/enc2_B_IO40: U4.33 (IO40); also elsewhere on the board
/ESP32-S3/enc2_SW_IO48: U4.25 (IO48); also elsewhere on the board
/ESP32-S3/enc3_A_IO2: U4.38 (IO2); also elsewhere on the board
/ESP32-S3/enc3_B_IO1: U4.39 (IO1); also elsewhere on the board
/ESP32-S3/enc3_SW_IO47: U4.24 (IO47); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R2.2, R3.2, R7.1, R8.2, R9.1, R10.2, S1.1, S1.2, S2.1, S2.2, U1.3 (GND), U1.11 (GND), U3.1 (ADJ/GND), U4.1 (GND), U4.40 (GND), U4.41 (GND); also elsewhere on the board
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R4.1
unnamed: J1.2, Q4.2 (E), R1.2, U2.5 (D1), U2.6 (D1)
unnamed: J2.A5 (CC1), R2.1
unnamed: J2.B5 (CC2), R3.1
unnamed: Q1.1 (G), R5.2
unnamed: Q2.1 (G), R6.2
unnamed: Q3.1 (B), Q3.3 (C), Q5.1 (B), R7.2
unnamed: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), Q3.2 (E), R4.2, U2.7 (D2), U2.8 (D2)
unnamed: Q4.1 (B), Q4.3 (C), Q6.1 (B), R8.1
unnamed: Q5.3 (C), R9.2, U2.2 (G2)
unnamed: Q6.3 (C), R10.1, U2.4 (G1)
unnamed: C2.1, U1.10 (V3)
VDD: C1.1, C3.1, Q5.2 (E), Q6.2 (E), U1.7 (VCC), U2.1 (S2), U2.3 (S1), U3.3 (INPUT)

Notes on the sheet:
ESP32 S3 WROOM1
5V→3.3V
理想ダイオードx2
Type-C 書き込み&シリアル用
書き込み回路
モババ

Parts:
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D84, D85, D86, D87, D88, D89, D90: 1N4148W; D_SOD-123
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66, SW67, SW68, SW69, SW70, SW71, SW72, SW73, SW74, SW75, SW76, SW77, SW78, SW79, SW80, SW81, SW82, SW83, SW84, SW85, SW86, SW87: SW_PUSH; CherryMX_Hotswap_via_1U

Connections:
/ESP32-S3/IO4: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1; also elsewhere on the board
/ESP32-S3/IO5: SW15.1, SW16.1, SW17.1, SW18.1, SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, SW24.1, SW25.1, SW26.1, SW27.1, SW28.1; also elsewhere on the board
/ESP32-S3/IO6: SW29.1, SW30.1, SW31.1, SW32.1, SW33.1, SW34.1, SW35.1, SW36.1, SW37.1, SW38.1, SW39.1, SW40.1, SW41.1, SW42.1, SW43.1; also elsewhere on the board
/ESP32-S3/IO7: SW44.1, SW45.1, SW46.1, SW47.1, SW48.1, SW49.1, SW50.1, SW51.1, SW52.1, SW53.1, SW54.1, SW55.1, SW56.1, SW57.1, SW58.1; also elsewhere on the board
/ESP32-S3/IO8: D5.1 (K), D12.2 (A), D19.1 (K), D26.2 (A), D33.1 (K), D41.2 (A), D48.1 (K), D56.2 (A), D63.1 (K), D71.2 (A), D78.1 (K), D86.2 (A); also elsewhere on the board
/ESP32-S3/IO9: D6.1 (K), D13.2 (A), D20.1 (K), D27.2 (A), D34.1 (K), D42.2 (A), D49.1 (K), D57.2 (A), D64.1 (K), D72.2 (A), D79.1 (K), D87.2 (A); also elsewhere on the board
/ESP32-S3/IO10: D7.1 (K), D14.2 (A), D21.1 (K), D28.2 (A), D35.1 (K), D43.2 (A), D50.1 (K), D58.2 (A), D65.1 (K), D73.2 (A), D80.1 (K), D88.2 (A); also elsewhere on the board
/ESP32-S3/IO11: D8.1 (K), D15.2 (A), D22.1 (K), D29.2 (A), D36.1 (K), D44.2 (A), D51.1 (K), D59.2 (A), D66.1 (K), D74.2 (A), D81.1 (K), D89.2 (A); also elsewhere on the board
/ESP32-S3/IO12: D9.1 (K), D16.2 (A), D23.1 (K), D30.2 (A), D37.1 (K), D45.2 (A), D52.1 (K), D60.2 (A), D67.1 (K), D75.2 (A), D82.1 (K), D90.2 (A); also elsewhere on the board
/ESP32-S3/IO13: D38.1 (K), D53.1 (K), D68.1 (K); also elsewhere on the board
/ESP32-S3/IO15: SW59.1, SW60.1, SW61.1, SW62.1, SW63.1, SW64.1, SW65.1, SW66.1, SW67.1, SW68.1, SW69.1, SW70.1, SW71.1, SW72.1, SW73.1; also elsewhere on the board
/ESP32-S3/IO16: SW74.1, SW75.1, SW76.1, SW77.1, SW78.1, SW79.1, SW80.1, SW81.1, SW82.1, SW83.1, SW84.1, SW85.1, SW86.1, SW87.1; also elsewhere on the board
/ESP32-S3/IO17: D3.1 (K), D10.2 (A), D17.1 (K), D24.2 (A), D31.1 (K), D39.2 (A), D46.1 (K), D54.2 (A), D61.1 (K), D69.2 (A), D76.1 (K), D84.2 (A); also elsewhere on the board
/ESP32-S3/IO18: D4.1 (K), D11.2 (A), D18.1 (K), D25.2 (A), D32.1 (K), D40.2 (A), D47.1 (K), D55.2 (A), D62.1 (K), D70.2 (A), D77.1 (K), D85.2 (A); also elsewhere on the board
unnamed: D3.2 (A), SW2.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW6.2
unnamed: D6.2 (A), SW8.2
unnamed: D7.2 (A), SW10.2
unnamed: D8.2 (A), SW12.2
unnamed: D9.2 (A), SW14.2
unnamed: D10.1 (K), SW1.2
unnamed: D11.1 (K), SW3.2
unnamed: D12.1 (K), SW5.2
unnamed: D13.1 (K), SW7.2
unnamed: D14.1 (K), SW9.2
unnamed: D15.1 (K), SW11.2
unnamed: D16.1 (K), SW13.2
unnamed: D17.2 (A), SW16.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW20.2
unnamed: D20.2 (A), SW22.2
unnamed: D21.2 (A), SW24.2
unnamed: D22.2 (A), SW26.2
unnamed: D23.2 (A), SW28.2
unnamed: D24.1 (K), SW15.2
unnamed: D25.1 (K), SW17.2
unnamed: D26.1 (K), SW19.2
unnamed: D27.1 (K), SW21.2
unnamed: D28.1 (K), SW23.2
unnamed: D29.1 (K), SW25.2
unnamed: D30.1 (K), SW27.2
unnamed: D31.2 (A), SW30.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW34.2
unnamed: D34.2 (A), SW36.2
unnamed: D35.2 (A), SW38.2
unnamed: D36.2 (A), SW40.2
unnamed: D37.2 (A), SW42.2
unnamed: D38.2 (A), SW43.2
unnamed: D39.1 (K), SW29.2
unnamed: D40.1 (K), SW31.2
unnamed: D41.1 (K), SW33.2
unnamed: D42.1 (K), SW35.2
unnamed: D43.1 (K), SW37.2
unnamed: D44.1 (K), SW39.2
unnamed: D45.1 (K), SW41.2
unnamed: D46.2 (A), SW45.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW49.2
unnamed: D49.2 (A), SW51.2
unnamed: D50.2 (A), SW53.2
unnamed: D51.2 (A), SW55.2
unnamed: D52.2 (A), SW57.2
unnamed: D53.2 (A), SW58.2
unnamed: D54.1 (K), SW44.2
unnamed: D55.1 (K), SW46.2
unnamed: D56.1 (K), SW48.2
unnamed: D57.1 (K), SW50.2
unnamed: D58.1 (K), SW52.2
unnamed: D59.1 (K), SW54.2
unnamed: D60.1 (K), SW56.2
unnamed: D61.2 (A), SW60.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW64.2
unnamed: D64.2 (A), SW66.2
unnamed: D65.2 (A), SW68.2
unnamed: D66.2 (A), SW70.2
unnamed: D67.2 (A), SW72.2
unnamed: D68.2 (A), SW73.2
unnamed: D69.1 (K), SW59.2
unnamed: D70.1 (K), SW61.2
unnamed: D71.1 (K), SW63.2
unnamed: D72.1 (K), SW65.2
unnamed: D73.1 (K), SW67.2
unnamed: D74.1 (K), SW69.2
unnamed: D75.1 (K), SW71.2
unnamed: D76.2 (A), SW75.2
unnamed: D77.2 (A), SW77.2
unnamed: D78.2 (A), SW79.2
unnamed: D79.2 (A), SW81.2
unnamed: D80.2 (A), SW83.2
unnamed: D81.2 (A), SW85.2
unnamed: D82.2 (A), SW87.2
unnamed: D84.1 (K), SW74.2
unnamed: D85.1 (K), SW76.2
unnamed: D86.1 (K), SW78.2
unnamed: D87.1 (K), SW80.2
unnamed: D88.1 (K), SW82.2
unnamed: D89.1 (K), SW84.2
unnamed: D90.1 (K), SW86.2

Board: 2 copper layers, 380.2 x 121.1 mm, 233 parts (136 on the bottom side), 140 nets.

File Davinci-Keyboard/jlcpcb/production_files/BOM-Davinci-Keyboard.csv (part):

Comment,Designator,Footprint,LCSC,Quantity
USB_C_Receptacle_USB2.0_16P,J2,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,,1
ESP32-S3-WROOM-1,U4,ESP32-S3-WROOM-1,,1
10k,R9,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Conn_01x02,J1,PinHeader_1x02_P2.54mm_Vertical,,1
OSG50603C1E,D1,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
0.1uF,C2,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
0.1uF,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
RST,S2,SW_SKRPACE010,,1
BOOT,S1,SW_SKRPACE010,,1
SW_PUSH,SW2,CherryMX_Hotswap_via_1U,,1
0.1uF,C6,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
SW_PUSH,SW3,CherryMX_Hotswap_via_1U,,1
22uF,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R11,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
OSG50603C1E,D2,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
SW_PUSH,SW1,CherryMX_Hotswap_via_1U,,1
5.1k,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
MMBT3906,Q4,SOT-23,,1
10k,R22,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
22uF,C7,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R24,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.01uF,C11,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.1uF,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10uF,C3,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R14,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R10,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.1uF,C4,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
AZ1117CH-3.3TRG1,U3,SOT-223_DIO-M,,1
10k,R16,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
5.1k,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R12,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
CH340K,U1,SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm,,1
10k,R13,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.01uF,C12,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R21,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
MMBT3906,Q3,SOT-23,,1
10k,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R19,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R25,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R23,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
BSS138,Q1,SOT-23,,1
0.01uF,C13,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R17,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
MMBT3906,Q5,SOT-23,,1
5k,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R18,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R15,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R26,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
5k,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.01uF,C14,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
0.01uF,C9,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
10k,R20,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.01uF,C10,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
BSS138,Q2,SOT-23,,1
FDS4935A,U2,SO-8_ONS-L,,1
SW_PUSH,SW87,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW86,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW85,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW84,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW83,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW82,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW81,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW80,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW79,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW78,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW77,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW76,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW75,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW74,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW73,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW72,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW71,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW70,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW69,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW68,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW67,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW66,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW65,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW64,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW63,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW62,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW61,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW60,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW59,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW58,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW57,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW56,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW55,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW54,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW53,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW52,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW51,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW50,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW49,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW48,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW47,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW46,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW45,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW44,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW43,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW42,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW41,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW40,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW39,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW38,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW37,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW36,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW35,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW34,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW33,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW32,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW31,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW30,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW29,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW28,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW27,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW26,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW25,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW24,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW23,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW22,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW21,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW20,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW19,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW18,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW17,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW16,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW15,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW14,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW13,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW12,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW11,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW10,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW9,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW8,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW7,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW6,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW5,CherryMX_Hotswap_via_1U,,1
SW_PUSH,SW4,CherryMX_Hotswap_via_1U,,1
1N4148W,D90,D_SOD-123,,1
1N4148W,D89,D_SOD-123,,1
1N4148W,D88,D_SOD-123,,1
1N4148W,D87,D_SOD-123,,1
1N4148W,D86,D_SOD-123,,1
1N4148W,D85,D_SOD-123,,1
1N4148W,D84,D_SOD-123,,1
1N4148W,D82,D_SOD-123,,1
1N4148W,D81,D_SOD-123,,1
1N4148W,D80,D_SOD-123,,1
1N4148W,D79,D_SOD-123,,1
1N4148W,D78,D_SOD-123,,1
1N4148W,D77,D_SOD-123,,1
1N4148W,D76,D_SOD-123,,1
1N4148W,D75,D_SOD-123,,1
1N4148W,D74,D_SOD-123,,1
1N4148W,D73,D_SOD-123,,1
1N4148W,D72,D_SOD-123,,1
1N4148W,D71,D_SOD-123,,1
1N4148W,D70,D_SOD-123,,1
1N4148W,D69,D_SOD-123,,1
1N4148W,D68,D_SOD-123,,1
1N4148W,D67,D_SOD-123,,1
1N4148W,D66,D_SOD-123,,1
1N4148W,D65,D_SOD-123,,1
1N4148W,D64,D_SOD-123,,1
1N4148W,D63,D_SOD-123,,1
1N4148W,D62,D_SOD-123,,1
1N4148W,D61,D_SOD-123,,1
1N4148W,D60,D_SOD-123,,1
1N4148W,D59,D_SOD-123,,1
1N4148W,D58,D_SOD-123,,1
1N4148W,D57,D_SOD-123,,1
1N4148W,D56,D_SOD-123,,1
1N4148W,D55,D_SOD-123,,1
1N4148W,D54,D_SOD-123,,1
1N4148W,D53,D_SOD-123,,1
1N4148W,D52,D_SOD-123,,1
1N4148W,D51,D_SOD-123,,1
1N4148W,D50,D_SOD-123,,1
1N4148W,D49,D_SOD-123,,1
1N4148W,D48,D_SOD-123,,1
1N4148W,D47,D_SOD-123,,1
1N4148W,D46,D_SOD-123,,1
1N4148W,D45,D_SOD-123,,1
1N4148W,D44,D_SOD-123,,1
1N4148W,D43,D_SOD-123,,1
1N4148W,D42,D_SOD-123,,1
1N4148W,D41,D_SOD-123,,1
1N4148W,D40,D_SOD-123,,1
1N4148W,D39,D_SOD-123,,1
1N4148W,D38,D_SOD-123,,1
1N4148W,D37,D_SOD-123,,1
1N4148W,D36,D_SOD-123,,1
1N4148W,D35,D_SOD-123,,1
1N4148W,D34,D_SOD-123,,1
1N4148W,D33,D_SOD-123,,1
1N4148W,D32,D_SOD-123,,1
1N4148W,D31,D_SOD-123,,1
1N4148W,D30,D_SOD-123,,1
1N4148W,D29,D_SOD-123,,1
1N4148W,D28,D_SOD-123,,1
1N4148W,D27,D_SOD-123,,1
1N4148W,D26,D_SOD-123,,1
1N4148W,D25,D_SOD-123,,1
1N4148W,D24,D_SOD-123,,1
1N4148W,D23,D_SOD-123,,1
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
## Commit log

2024-12-30 esp32
2025-01-01 20$越え
